# Keil uVision project example.uvprojx, settings and files
target target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example +hex
  AfterMake: fromelf.exe --bin -o .\Objects\@L.bin .\Objects\@L.axf
  AfterMake: ..\..\tools\srecord-1.63-win32\srec_cat .\Objects\@L.hex -intel -o .\Objects\@L.srec
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,CPATAIN_DESIGN,_UDEBUG
  c include: ..\..\sdk\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\..\sdk\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\sdk\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\sdk\STM32Cube_FW_F2_V1.8.0\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\sdk\STM32Cube_FW_F2_V1.8.0\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\inc;inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./src/: startup_stm32f10x_cl.s system_stm32f10x.c
  group driver
    ../../sdk/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group rtos
    ../../sdk/STM32Cube_FW_F2_V1.8.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../sdk/STM32Cube_FW_F2_V1.8.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../sdk/STM32Cube_FW_F2_V1.8.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group bsp
    ../../src/: can.c i2c.c uart.c
    ../../src/stm32f10x/: can_stm32f10x.c flash_ctrl_stm32f10x.c i2c_stm32f10x.c spi_stm32f10x.c system_stm32f10x.c timer_stm32f10x.c uart_stm32f10x.c
  group user
    ../: main.c rtos.c test.c
